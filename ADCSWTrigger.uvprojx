# Keil uVision project ADCSWTrigger.uvprojx, settings and files
target ADCSWTrigger (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ADCTestMain.c ST7735.c ST7735.h Sound.c Sound.h Timer.c Timer.h Switches.c Switches.h
    ../inc/: ADCSWTrigger.c PLL.c LaunchPad.c
software components: CMSIS:CORE 5.0.2
